# Keil uVision project Blinky.uvprojx, settings and files
target V2M-MPS2 (6170000::V6.17::.\ARMCLANG_6.17)
  device: IOTKit_ARMv8MML ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.4.2
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") TZ CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=7 wLevel=3
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA __USE_SECURE
  c misc: -Wno-padded
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  group Source Files
    ./: Blinky.c stdout_USART.c
  group Documentation
    ./: Abstract.txt
target V2M-MPS2 DAP (6170000::V6.17::.\ARMCLANG_6.17)
  device: IOTKit_ARMv8MML ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.4.2
  cpu: as above
  output: Blinky
  c flags: Optim=7 wLevel=3
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA __USE_SECURE
  c misc: -Wno-padded
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0, Board Support:Buttons 2.0.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:USART 1.0, Device:Startup 1.1.1
